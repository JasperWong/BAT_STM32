# Keil uVision project bat.uvprojx, settings and files
target bat (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Crazepony +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\StartUp;.\Src;.\Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_pwr.c
  group Src
    ./Src/: BAT_I2C.c BAT_MPU6050.c BAT_PID.c MahonyAHRS.c main.c stm32f10x_it.c BAT_LPF.c BAT_NRF.c BAT_TIME_SYSTEM.c BAT_REMOTE.c BAT_AHRS.c BAT_CONTROL.c BAT_BLE.c BAT_PASER.c
